# Keil uVision project LK_StdPeriph.uvprojx, settings and files
target Linko 03x Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC038Y6P8 Linko
  pack: Linko.LKS03x.1.1.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS_MC_Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FreeMaster;.\Include;.\LKS32MC03x_Periph_Driver\include;.\RTT;.\Kernal_Source;.\USER_APP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group AppFunction
    ./AppFunction/: Global_Variable.c hardware_init.c interrupt.c System_Init.c Task_Scheduler.c state_machine.c fault_detection.c Process_Control.c PowerCalculation.c SpeedScan.c HeatControl.c
  group Kernel_Code
    ./Kernal_Source/: main.c MC_math.c App2Core.c FOC_Drive.c SignalChain_Sample.c PID_regulators.c MC_hall.c LKS03x_FluxOBS_V2p16_0624.lib
  group RTT_Debug
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Periph_Driver
    ./LKS32MC03x_Periph_Driver/Source/: lks32mc03x_adc.c lks32mc03x_cmp.c lks32mc03x_DMA.c lks32MC03x_Flash.c lks32mc03x_gpio.c lks32mc03x_hall.c lks32mc03x_I2C.c lks32mc03x_IWDG.c lks32mc03x_MCPWM.c lks32mc03x_spi.c lks32mc03x_sys.c lks32mc03x_timer.c lks32mc03x_uart.c startup_lks32mc03x.s lks32mc03x_nvr.lib
  group Include
    ./Include/: function_config.h hardware_config.h MC_Parameter.h
  group USER
    ./Include/: HeatControl.h
  group USER_APP
    ./USER_APP/: USER_APP.c USER_APP.h lcd.c lcd.h button.c button.h temp_sample.c temp_sample.h
software components: CMSIS:CORE 5.1.1
